Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: verso_120x70_h_6_shower_tray.ifc
Time: 2017-09-15T09:53:19
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Verso 120x70 h.6 Shower Tray
ePset_BIMobject_Lena - SHOWER_TRAY_COLOUR: Bianco lucido A00; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Verso 120x70 h.6 Shower Tray; SKU (BO_prodsku): catalano_shower_verso_120x70_cod_170120H600; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): http://www.catalano.it/; ProductFamily (BO_prodfam): Verso H6; ProductGroup (BO_prodgroup): Shower Tray; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; EditionNumber (BO_edinum): 1; Width (BO_width): 1200; Height (BO_height): 60; Depth (BO_depth): 700; Weight (BO_weight): 38; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/catalano_shower_verso_120x70_cod_170120H600; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/catalano_shower_verso_120x70_cod_170120H600; ProductUrl (BO_producturl): http://www.catalano.it/en/products/shower-trays/piatti-doccia-verso-120x70-70120h600/; ProductCertification (BO_prodcert): http://www.ceramicacatalano.it/conformita/Declaration-of-Performance-Shower-tray.pdf; TechnicalDescription (BO_techcert): http://www.ceramicacatalano.it/allegati_schede/schede-tecniche/PIATTI-DOCCIA/170120H600.pdf; EanCode (BO_ean): 8032919989017; MaterialMain (BO_mainmat): Ceramics; MaterialSecondary (BO_secmat): Fireclay; BimObjectCategory (BO_bocat): Shower trays; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspcCode (BO_unspc): 30181503; Uniclass14Code (BO_uniclass_1_4_code): L72143; Uniclass14Description (BO_uniclass_1_4_desc): Shower trays; Uniclass20Code (BO_uniclass_2_0_code): PR-35-06-84; Uniclass20Description (BO_uniclass_2_0_desc): Shower Trays; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_06_84; Uniclass2015Description (BO_uniclass2015_desc): Shower trays; NBSReference (BO_nbs_ref): 35-06-84; NBSReferenceDescription (BO_nbs_desc): Shower Trays; OmniClassCode (BO_omniclass_code): 23-31 17 00; OmniClassDescription (BO_omniclass_name): Showers; MasterFormat2014Code (BO_masterformat2014_code): 22 41 23; MasterFormat2014Description (BO_masterformat2014_name): Residential Showers; UniFormat2Code (BO_uniformat2_code): C10; UniFormat2Description (BO_uniformat2_name): INTERIOR CONSTRUCTION; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
